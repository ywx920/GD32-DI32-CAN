# Keil uVision project GD32F450ZE_DI1014.uvprojx, settings and files
target GD32450Z_EVAL (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: GD32F450ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(25000000) ELITTLE
  output: DIM-DI-1014-250k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\Library\Fimware\GD32F4xx_standard_peripheral\Include;..\Library\Fimware\CMSIS\GD\GD32F4xx\Include;..\Library\Utilities;..;..\Library\Fimware\CMSIS;..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c gd32f4xx_it.c systick.c ad8251.c sn74hc595d.c ad7928.c can.c led.c irq.c task.c dim_input.c di_protocol.c FNRAM.c
  group CMSIS
    ../Library/Fimware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../Library/Fimware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../Library/Utilities/: gd32f450z_eval.c
  group Startup
    ../Library/Fimware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
